# Repository JayesonLS/8-bit-ide

File README.md:

# 8-bit-ide

WIP on a solid state replacement for 8 bit IDE hard drives.

This project is looking at implementing replacements for:

1. The somewhat standard drive type used by PCs with 8 bit ISA bus.
   This uses a the same style of 40 pin header as ATA however
   the pinout and protocols are different. This is referred to
   by various names such as XT-BUS, XT-IDE, IDE-XT or XTA. We
   will refer to this as XTA.
   
   XTA should not be confused with the much more modern XTIDE
   Universal BIOS and cards which were created to adapt ATA
   devices to XT PCs. It should also not be confused with the ATA
   8 bit transfer mode available in many compact flash cards.
   
2. The IBM proprietary 8 bit IDE hard drive type with card edge
   connector. These were used in the IBM PS/2 Model 25 and Model 30
   as well as early 8086 and 80286 IBM PS/1's. We will refer
   to this IBM 8-bit DBA (Direct BUS Attachment). 

   IBM 8-bit DBA should not be confused with IBM's MCA 
   (Microchannel) DBA hard drive type. This type uses a card edge
   connector and integrates the drive controller into the drive.
   To the system BIOS, these devices look like the IBM MCA ESDI
   hard drive controller card and so are sometimes confusingly 
   referred to as ESDI hard drives. This project does not plan
   to implement a replacement for the IBM MCA DBA "ESDI" drives.

More information available in this VCFED discussion:
https://www.vcfed.org/forum/forum/genres/pcs-and-clones/1224016-8-bit-ide-xta-replacement-project

## KiCad design XTA-35-TH/XTA-35-TH.kicad_pcb

Parts:
C1, C2, C3: 0.1uF; C_1206_3216Metric; LCSC C24497
D1: MBR120/130; D_SOD-123
J1: XTA_Connector; IDC-Header_2x20_P2.54mm_Horizontal
J2: XTA Power; conn_hdd_15-24-4441
J3: LED; PinHeader_1x02_P2.54mm_Horizontal
J4: SD0; SD_Board
J5: SD1; SD_Board
J6: DEBUG; PinHeader_1x03_P2.54mm_Vertical
MH1, MH2, MH3, MH4: MountingHole_Pad; Reinforcing_Ring_Partial
MH5, MH6, MH7, MH8: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
R1, R2: 120R; R_1206_3216Metric; LCSC C17909
R3, R4, R5, R6: 10K; R_1206_3216Metric; LCSC C17902
SW1: Boot Override; SW_PUSH_6mm
SW2: Reset; SW_PUSH_6mm
U1, U2: 74LVC245; DIP-20_W7.62mm_Socket
U3: 74HCT125; DIP-14_W7.62mm_Socket
U5: Raspberry Pi Pico; RPi_Pico_SMD_TH

Connections:
+3V3: C1.1, C2.1, J4.1 (3V3), J5.1 (3V3), R5.1, R6.1, U1.20 (VCC), U2.20, U5.36 (3V3)
/3V3_EN: U5.37 (3V3_EN)
/5V_IN: D1.2 (A), J2.4
/ADC_VREF: U5.35 (ADC_VREF)
/MOUNTING_1: MH1.1
/MOUNTING_2: MH2.1
/MOUNTING_3: MH3.1
/MOUNTING_4: MH4.1
/RUN: SW2.1, U5.30 (RUN)
/SWCLK: J6.1, U5.41 (SWCLK)
/SWDIO: J6.3, U5.43 (SWDIO)
/VBUS: U5.40 (VBUS)
/~BOOT_OVERRIDE: SW1.1, U5.31 (GP26)
A0: J1.35 (A0), U2.17
A0_3V3: U2.3, U5.20 (GP15)
A1: J1.33 (A1), U2.18
A1_3V3: U2.2, U5.21 (GP16)
AEN: J1.21 (AEN), U2.14
AEN_3V3: U2.6, U5.24 (GP18)
D0: J1.17 (D0), U1.18 (B0)
D0_3V3: U1.2 (A0), U5.7 (GP5)
D1: J1.15 (D1), U1.17 (B1)
D1_3V3: U1.3 (A1), U5.9 (GP6)
D2: J1.13 (D2), U1.16 (B2)
D2_3V3: U1.4 (A2), U5.10 (GP7)
D3: J1.11 (D3), U1.15 (B3)
D3_3V3: U1.5 (A3), U5.11 (GP8)
D4: J1.9 (D4), U1.14 (B4)
D4_3V3: U1.6 (A4), U5.12 (GP9)
D5: J1.7 (D5), U1.13 (B5)
D5_3V3: U1.7 (A5), U5.14 (GP10)
D6: J1.5 (D6), U1.12 (B6)
D6_3V3: U1.8 (A6), U5.15 (GP11)
D7: J1.3 (D7), U1.11 (B7)
D7_3V3: U1.9 (A7), U5.16 (GP12)
DATA_DIR: R4.1, U1.1 (A->B), U5.29 (GP22)
DRQ: J1.29 (DRQ), U3.3
GND: C1.2, C2.2, C3.2, J1.2 (GND), J1.4 (GND), J1.6 (GND), J1.8 (GND), J1.10 (GND), J1.12 (GND), J1.14 (GND), J1.16 (GND), J1.18 (GND), J1.19 (GND), J1.22 (GND), J1.24 (GND), J1.26 (GND), J1.28 (GND), J1.30 (GND), J1.32 (GND), J1.36 (GND), J1.38 (GND), J1.40 (GND), J2.2, J2.3, J4.6 (GND), J5.6 (GND), J6.2, R4.2, SW1.2, SW2.2, U1.10 (GND), U1.19 (CE), U2.1, U2.10, U2.19, U3.7 (GND), U3.9, U3.12, U5.3 (GND), U5.8 (GND), U5.13 (GND), U5.18 (GND), U5.23 (GND), U5.28 (GND), U5.33 (GND), U5.38 (GND), U5.42 (GND)
IRQ: J1.31 (IRQ), U3.6
unnamed: J3.1, R2.2
unnamed: J3.2, R1.1
unnamed: R1.2, U3.11
unnamed: R3.1, U3.2, U3.5
SD0_CS: J4.2 (CS), U5.2 (GP1)
SD1_CS: J5.2 (CS), U5.6 (GP4)
SPI_RX: J4.5 (MISO), J5.5 (MISO), U5.1 (GP0)
SPI_SCK: J4.4 (CLK), J5.4 (CLK), U5.4 (GP2)
SPI_TX: J4.3 (MOSI), J5.3 (MOSI), U5.5 (GP3)
VSYS: C3.1, D1.1 (K), R2.1, R3.2, U3.14 (VCC), U5.39 (VSYS)
~CS: J1.37 (~CS), U2.13
~CS~_3V3: U2.7, U5.22 (GP17)
~DACK: J1.27 (~DACK), U2.15
~DACK~_3V3: U2.5, U5.17 (GP13)
~DRIVE_ACTIVE: J1.39 (~ACTIVE), U3.8
~DRIVE_ACTIVE~_3V3: U3.10, U3.13, U5.32 (GP27)
~DRQ~_3V3: R5.2, U3.1, U5.26 (GP20)
~IOR: J1.25 (~IOR), U2.12
~IOR~_3V3: U2.8, U5.25 (GP19)
~IOW: J1.23 (~IOW), U2.11
~IOW~_3V3: U2.9, U5.19 (GP14)
~IRQ~_3V3: R6.2, U3.4, U5.27 (GP21)
~RESET: J1.1 (~RESET), U2.16
~RESET~_3V3: U2.4, U5.34 (GP28)

Notes on the sheet:
On GP26-28, there is a clamp diode to 3.3v, should one be needed.
IDE CONNECTOR
5V / 3.3V CONVERSION
POWER
RASPBERRY PI PICO
The PICO already has a 47uF cap on both the 5v and 3.3v side of the regulator, so no bulk capacitor is included in this design.
SD CONNECTORS
MOUNTING

Board: 4 copper layers, 100.0 x 98.7 mm, 30 parts (0 on the bottom side), 56 nets.

File XTA-35-TH/Gerbers/XTA-35-TH-bom.csv:

Comment,Designator,Footprint,LCSC
"0.1uF","C1,C2,C3,C4","Capacitor_SMD:C_1206_3216Metric"," C24497"
"MBR120/130","D1","Diode_SMD:D_SOD-123",""
"XTA_Connector","J1","Connector_IDC:IDC-Header_2x20_P2.54mm_Horizontal",""
"XTA Power","J2","w_conn_pc:conn_hdd_15-24-4441",""
"LED","J3","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Horizontal",""
"SD0","J4","00Common:SD_Board",""
"SD1","J5","00Common:SD_Board",""
"Debug","J6","Connector_PinHeader_2.54mm:PinHeader_1x06_P2.54mm_Vertical",""
"MountingHole_Pad","MH1,MH2,MH3,MH4","00Common:Reinforcing_Ring_Partial",""
"MountingHole_Pad","MH5,MH6,MH7,MH8","MountingHole:MountingHole_3.2mm_M3_Pad",""
"120R","R1,R2","Resistor_SMD:R_1206_3216Metric","C17909"
"10K","R3,R4,R5,R6,R7,R8,R9","Resistor_SMD:R_1206_3216Metric","C17902"
"Config","SW1","00Common:SW_DIP_SPSTx04",""
"Boot Internal","SW2","Button_Switch_THT:SW_PUSH_6mm",""
"Reset","SW3","Button_Switch_THT:SW_PUSH_6mm",""
"74LVC245","U1,U2","Package_DIP:DIP-20_W7.62mm_Socket",""
"74HCT125","U3","Package_DIP:DIP-14_W7.62mm_Socket",""
"74HC165","U4","Package_DIP:DIP-16_W7.62mm_Socket",""
"Raspberry Pi Pico","U5","Pico:RPi_Pico_SMD_TH",""

## KiCad design HCT145Interposer/HCT145Interposer.kicad_pcb

Parts:
C1: 0.1uF; C_Disc_D6.0mm_W2.5mm_P5.00mm; LCSC C24497
J1: Header; DIP-14_W7.62mm_Socket
J2: Conn_01x01; PinHeader_1x01_P2.54mm_Vertical
U1: 74LVC245; DIP-20_W7.62mm_Socket

Connections:
+3V3: C1.1, J2.1, U1.20 (VCC)
+5V: J1.14
/TIED_TO_5V_1: J1.2
/TIED_TO_5V_2: J1.5
/TIED_TO_GND_1: J1.9
/TIED_TO_GND_2: J1.12
/~DRIVE_ACTIVE: J1.8
/~DRIVE_ACTIVE~_IN_3V3_1: J1.10, J1.11
/~DRIVE_ACTIVE~_IN_3V3_2: J1.13
GND: C1.2, J1.7, U1.1 (A->B), U1.3 (A1), U1.4 (A2), U1.6 (A4), U1.7 (A5), U1.8 (A6), U1.9 (A7), U1.10 (GND), U1.19 (CE)
NEW_DRQ_IN: J1.3, U1.18 (B0)
NEW_DRQ_OUT_3V3: J1.1, U1.2 (A0)
NEW_IRQ_IN: J1.6, U1.15 (B3)
NEW_IRQ_OUT_3V3: J1.4, U1.5 (A3)

Board: 2 copper layers, 15.2 x 27.9 mm, 4 parts (0 on the bottom side), 7 nets.

## KiCad design PinRemapInterposer/PinRemapInterposer.kicad_pcb

Parts:
J1: Header; DIP-40_W15.24mm_Socket
J2: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
R1: 10K; R_1206_3216Metric; LCSC C17902
U5: Raspberry Pi Pico; RPi_Pico_SMD_TH

Connections:
3V3_EN: J1.37, U5.37 (3V3_EN)
+3V3: J1.36, U5.36 (3V3)
A0_3V3: J1.16, U5.27 (GP21)
A1_3V3: J1.17, U5.29 (GP22)
ADC_VREF: J1.35, U5.35 (ADC_VREF)
AEN_3V3: J1.19, U5.26 (GP20)
CFG_DATA: J1.1, U5.9 (GP6)
D0_3V3: J1.6, U5.11 (GP8)
D1_3V3: J1.7, U5.12 (GP9)
D2_3V3: J1.9, U5.14 (GP10)
D3_3V3: J1.10, U5.15 (GP11)
D4_3V3: J1.11, U5.16 (GP12)
D5_3V3: J1.12, U5.17 (GP13)
D6_3V3: J1.14, U5.19 (GP14)
D7_3V3: J1.15, U5.20 (GP15)
DATA_DIR: J1.29, R1.1, U5.10 (GP7)
GND: J1.3, J1.8, J1.13, J1.18, J1.23, J1.28, J1.33, J1.38, J2.2, R1.2, U5.3 (GND), U5.8 (GND), U5.13 (GND), U5.18 (GND), U5.23 (GND), U5.28 (GND), U5.33 (GND), U5.38 (GND), U5.42 (GND)
RUN: J1.30, U5.30 (RUN)
SD0_CS: J1.4, U5.2 (GP1)
SD1_CS: J1.5, U5.6 (GP4)
SPI_RX: J1.21, U5.1 (GP0)
SPI_SCK: J1.24, U5.4 (GP2)
SPI_TX: J1.25, U5.5 (GP3)
SWCLK: J2.3, U5.41 (SWCLK)
SWDIO: J2.1, U5.43 (SWDIO)
VBUS: J1.40, U5.40 (VBUS)
VSYS: J1.39, U5.39 (VSYS)
~CS~_3V3: J1.31, U5.25 (GP19)
~DACK~_3V3: J1.20, U5.21 (GP16)
~DRIVE_ACTIVE~_3V3: J1.2, U5.7 (GP5)
~DRQ~_3V3: J1.34, U5.31 (GP26)
~IOR~_3V3: J1.26, U5.22 (GP17)
~IOW~_3V3: J1.22, U5.24 (GP18)
~IRQ~_3V3: J1.32, U5.32 (GP27)
~RESET~_3V3: J1.27, U5.34 (GP28)

Notes on the sheet:
RASPBERRY PI PICO

Board: 2 copper layers, 29.2 x 55.9 mm, 4 parts (0 on the bottom side), 35 nets.

## KiCad design XTA-35/XTA-35.kicad_pcb

Board: 4 copper layers, 222.1 x 98.7 mm, 23 parts (0 on the bottom side), 8 nets, no tracks yet.

Parts:
C1, C2, C3, C4: 0.1uF; C_1206_3216Metric
D1, D2: MBR120/130; D_SOD-123
J1: XTA_Connector; PinHeader_2x20_P2.54mm_Horizontal
R1, R2: 120R; R_1206_3216Metric
R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14: 10K; R_1206_3216Metric
U4: RPI_PICO; RPi_Pico_SMD_TH
XTA Power: J3; conn_hdd_15-24-4441

Connections:
+3V3: C1.1, C2.1, C3.1, D2.1, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, U4.36
CFG_DATA: R14.2, U4.34
DBG_RX: R14.1, U4.1
GND: C1.2, C2.2, C3.2, C4.2, J1.2, J1.4, J1.6, J1.8, J1.10, J1.12, J1.14, J1.16, J1.18, J1.19, J1.22, J1.24, J1.26, J1.28, J1.30, J1.32, J1.36, J1.38, J1.40, R6.2, U4.3, U4.8, U4.13, U4.18, U4.23, U4.28, U4.33, U4.38
IBM_SENSE_3V3: D2.2, R5.2, R6.1
unnamed: R3.2, R4.1
unnamed: R4.2, R5.1
VSYS: C4.1, D1.1, R2.1, U4.39

## Code that names these connections

File Firmware/Common/IoConfig.h:

// Copyright (C) 2021 Titanium Studios Pty Ltd 

#pragma once

// Centralized configuration for RP2040 GPIO's. 
class IoConfig
{
public:
    // Pin assignments.
    static const uint SPI_RX = 0;
    static const uint SD0_CS = 1;
    static const uint SPI_SCK = 2;
    static const uint SPI_TX = 3;
    static const uint SD1_CS = 4;
    static const uint D0 = 5;
    static const uint D1 = 6;
    static const uint D2 = 7;
    static const uint D3 = 8;
    static const uint D4 = 9;
    static const uint D5 = 10;
    static const uint D6 = 11;
    static const uint D7 = 12;
    static const uint INV_DACK = 13;
    static const uint INV_IOW = 14;
    static const uint A0 = 15;
    static const uint A1 = 16;
    static const uint INV_CS = 17;
    static const uint AEN = 18;
    static const uint INV_IOR = 19;
    static const uint INV_DRQ = 20;
    static const uint INV_IRQ = 21;
    static const uint DATA_DIR = 22;

    // Pico specific GPIO assignments.
    static const uint PICO_PS_MODE = 23; // We always want 0 for PFM = higher noise and efficiency.
    static const uint PICO_VBUS_SENSE = 24; // High when USB power present.
    static const uint PICO_LED = 25; // The built in LED.

    // These next two have been mapped to i2c pins so we have the option
    // later of switching to a PCF8574 bus expander and being able to
    // detect it.  
    static const uint INV_BOOT_OVERRIDE = 26; // Also ADC0.
    static const uint INV_DRIVE_ACTIVE = 27;  // Also ADC1.
    static const uint INV_RESET = 28;         // Also ADC2.
    
    static const uint PICO_VSYS_SENSE = 29;   // Also ADC3. Intended to be read with the ADC.

    // Pin groupings.
    static const uint INITIAL_INPUTS =
        (1 << SPI_RX) | (1 << SD0_CS) | (1 << SPI_SCK) | (1 << SPI_TX) | (1 << SD1_CS) | 
        (1 << D0) | (1 << D1) | (1 << D2) | (1 << D3) | (1 << D4) | (1 << D5) | (1 << D6) | (1 << D7) |
        (1 << INV_DACK) | (1 << INV_IOR) | (1 << INV_IOW) | (1 << INV_CS) | (1 << AEN) || (1 << A0) | (1 << A1); 
#ifdef NEW_BOARD
    static const uint INITIAL_OUTPUTS_LOW = (1 << DATA_DIR);
    static const uint INITIAL_OUTPUTS_HIGH = (1 << INV_DRQ) | (1 << INV_IRQ) | (1 << PICO_LED);
#else
    static const uint INITIAL_OUTPUTS_LOW = 0;
    static const uint INITIAL_OUTPUTS_HIGH = (1 << INV_DRQ) | (1 << INV_IRQ) | (1 << PICO_LED) | (1 << DATA_DIR);
#endif
    static const uint EXTERNAL_PULL_PINS = INITIAL_OUTPUTS_LOW | INITIAL_OUTPUTS_HIGH;
    static const uint INITIAL_OUTPUTS = INITIAL_OUTPUTS_LOW | INITIAL_OUTPUTS_HIGH;
    static const uint INITIAL_INPUTS_AND_OUTPUTS = INITIAL_INPUTS | INITIAL_OUTPUTS;

    static const uint READ_DRIVE_PINS =
        (1 << D0) | (1 << D1) | (1 << D2) | (1 << D3) | (1 << D4) | (1 << D5) | (1 << D6) | (1 << D7) |
        (1 << DATA_DIR);

    // Method that should be called very early in startup process
    // to configure initial IO pin state. 
    static void PreInitialzieIo();

    static void FinishInitializeIo();
};

File Firmware/LogicAnalyzer/LogicAnalyzer.h:

// Copyright (C) 2021 Titanium Studios Pty Ltd 

#pragma once

#include <pico/stdlib.h>
#include <hardware/pio.h>
#include <vector>

class LogicAnalyzer
{
public:
    static const uint CAPTURE_START_PIN = 4;
    static const uint CAPTURE_PIN_COUNT = 25; // This value should match num_pin_bits in LogicAnalyzer.pio. 

    // Do not initialize these pins for PIO.
    // BOOT_OVERRIDE, ~DRIVE_ACTIVE, 3x Pico internal pins including LED.
    // TODO: Final hardware will move BOOT_OVERRIDE and ~DRIVE_ACTIVE  
    static const uint SKIP_PIN_MASK = (1 << 2) | (1 << 3) | (1 << 23) | (1 << 24) | (1 << 25);
    
    // Set these pins to pullup.
    // DATA_DIR, ~IRQ, ~DRQ.
    // TODO: Final hardware will flip the direction of DATA_DIR
    static const uint PULLUP_PIN_MASK = (1 << 22) | (1 << 27) | (1 << 28);

    enum class CaptureType
    {
        Sample,
        DataValues
    };

    enum class CpuClock
    {
        Standard, // 125 MHz.
        Overclock2x,
        Overclock3x // Must execute from ram or make compile time changes for /4 flash clock speed.
    };

    class Sample
    {    
    public:
        // These should match the values in logic_analyzer.pio.
        static const int NUM_DATA_BITS = 8;
        static const int NUM_ADDR_BITS = 2;
        static const uint NUM_PIN_BITS = CAPTURE_PIN_COUNT;
        static const uint NUM_TIMESTAMP_BITS = 32-NUM_PIN_BITS;

        bool IsValid() const { return *((const uint32_t *)this) != 0xFFFFFFFF; }

        uint GetData() const { return data; }
        uint GetAddr() const { return addr; }
        uint GetAen() const { return aen; }
        uint GetInvDack() const { return inv_dack; }
        uint GetInvIow() const { return inv_iow; }
        uint GetInvIor() const { return inv_ior; }
        uint GetInvReset() const { return inv_reset; }
        uint GetInvCs() const { return inv_cs; }
        uint GetIrq() const { return irq; }
        uint GetDrq() const { return drq; }
        uint GetDataDir() const { return data_dir; }
        uint GetTimeStamp() const { return -timeStamp & ((1 << NUM_TIMESTAMP_BITS)-1); }

        uint GetRawPinBits() const { return *((uint32_t *)this) & ((1 << NUM_PIN_BITS)-1); }

        bool operator==(const Sample& other) const;

        void ClearTimeStamp() { timeStamp = 0; }
        void MarkInvalid() { *((uint32_t *)this) = 0xFFFFFFFF; }

    private:
        uint data : NUM_DATA_BITS;
        uint addr : NUM_ADDR_BITS;
        uint aen : 1;
        uint inv_dack : 1;
        uint ingore1 : 1; //SPI_RX
        uint inv_iow : 1;
        uint ignore2 : 1; // SPI_SCK
        uint ignore3 : 1; // SPI_TX
        uint inv_ior : 1;
        uint inv_reset : 1;
        uint data_dir : 1;
        uint ignore5 : 3; // Internal GPIOs.
        uint inv_cs : 1;
        uint irq : 1;
        uint drq : 1;
        uint timeStamp : NUM_TIMESTAMP_BITS;

        static_assert(NUM_PIN_BITS + NUM_TIMESTAMP_BITS == 32); 
    };

    static_assert(sizeof(Sample) == 4);

    LogicAnalyzer(PIO pio, CaptureType captureType, size_t maxSampleCount);
    ~LogicAnalyzer();

    void InitSampling();
    void StartSampling(CpuClock cpuClock);
    void StopSampling();
    
    bool IsSamplingComplete();

    void PostProcessSamples();

    const std::vector<Sample> &GetSamples() const { return samples; }

private:
    void InitPins();
    void InitStateMachines();
    void InitDma();
    void SetCpuClock(CpuClock cpuClock);

    bool initialized = false;
    CpuClock currentClock = CpuClock::Standard;

    std::vector<Sample> samples;

    CaptureType captureType;

    PIO pio = nullptr;
    uint sm = 0xAA55;
    uint programOffset = 0xAA55; 

    uint dmaChan = 0xAA55;
};

## Commit log

2021-10-12 Early start on a hardware design. Has an ATMEGA328 which is likely to change, however the XTA connector part of the schematic will be useful.
2021-10-12 Initial work on PicoFirmware experiments. Just a hello-world shell at the moment.
2021-10-14 Firmware now has a basic PIO program added and compiling (untested).
2021-10-15 Add code to use PIO program. There is a problem: see comments above pio_sm_put_blocking. Plan to discard current code and copy over from hello_pio - just committing this for reference.
2021-10-15 Rolled test PIO out functionality back to a simple single bit output. Serial does work in this case.
2021-10-16 Simple parallel PIO output.
2021-10-16 Simple parallel PIO output, now with a single sideset pin added.
2021-10-16 Replace outisa PIO program with earlier version that is written to mimmic ISA bus timings.
2021-10-16 Fix timing if isaout PIO: it was previoulsy running at half the desired speed.
2021-10-16 Rename XTA-8-bit-ide to 8-bit-ide-35. The plan is to use the same board for both IBM and XTA implementations.
2021-10-16 Start redoing schematic. Add library symbols for XTA and IBM interfaces.
2021-10-16 Add symbol for RPi Pico, do more schematic work.
2021-10-17 Mostly finish initial pass at schematic. Still needs SD connectors.
2021-10-17 Add Pico design files and set up on a pcb.
2021-10-22 Small schematic changes. Add outline of XTA board.
2021-10-22 Add smisioto libraries for HDD power connector.
2021-10-22 Add power and IDE cable connector. Add holes for mounting to 2.5" to 3.5" HDD adapter.
2021-10-22 Shrink board to fit in 100x100.
2021-10-22 Rename board to XTA-35. There will be different board variants for XTA 2.5 and IBM 8 bit.
2021-10-22 A bit more board/footprint work.
2021-10-22 Rename XTA-35 to XTA-35-TH. There is likely to be an SMD layout if these go into production.
2021-10-22 Misc board work.
2021-10-22 More board work.
2021-10-22 Lots of board layout.
2021-10-22 Board layout WIP.
2021-10-23 Lots of board layout work.
2021-10-24 Finished first pass on copper layers.
2021-10-24 Finished first pass of board design.
2021-10-24 Minor silkscreen changes.
2021-10-25 Production files. Also added a relief USB connector body after sending for production.
2021-10-25 Added a couple of TODO's to XTA drive schematic.
2021-10-25 Add interposer for reversing the 74HCT145 directions. Includes 3.3v level shifting. This is so we can use a modified drive to monitor all interesing signals on the ISA bus - that is, use it as a logi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
2021-10-25 Add gerbers for the HC145 interposer.
2021-10-28 Relocate firmware to sub-folder to allow more than one firmware.
2021-10-28 Copy XtaFirmware to LogicAnalyzer as a starting point.
2021-10-28 LogicAnalyzer project now compiling.
2021-10-29 Initial work setting up logic analyzer class.
2021-10-29 Current incomplete code for logic analyzer is running now.
2021-10-29 Calling more of the WIP logic analyzer code.
2021-10-29 Simple random buffer fill and dump to serial is working.
2021-10-29 Manually pulling from la_sample PIO is working correctly. Confirmed that X-- with 0 does proceed to -1.
2021-10-29 Add overclocking code. Also join sampling state machine FIFO.
2021-10-29 DMA to memory is now working.
2021-10-29 Remove printf.
2021-10-29 Add more overclocking options. Never did get 3x overclock to run - tried both running from SRAM (which didn't seem to deploy to the Pico properly) and changing QSPI flash speed (had CMAKE troubles).
2021-10-29 Fix LED value count.
2021-10-30 Remove-dupes state machine now working. DMA still needs to be hooked up.
2021-10-30 Tidy up PIO comments. Add a wrap target to sample state machine to facilitate possible additon of some trigger condition.
2021-10-30 Add bit reduce and placeholder post processing SMs. Tested however DMA still needs to be hooked up.
2021-10-30 Reorder some fields in header.
2021-10-30 Manually pump data through fifos in preparation for DMA.
2021-10-30 Rework Sample structure to use bit packing.
2021-10-30 Fix DMA to memory DREQ to use correct state machine. This fixes some bad data issues. Other minor changes.
2021-10-30 Turns out that direct dma from pio to pio is not possible. Instead a ping-ping buffer in memory is required and this is just too much trouble. So falling back to a single state machine. More work is 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
2021-10-30 Clean up state machine code to a single program which decrements timestamp, samples pins, and discards duplicate values. Takes 7 cylces per loop for 35MHz sampling rate with 250MHz overclock.
2021-10-30 Added trigger conditions.
2021-10-31 Rework logic analyzer to match XTA-35 board. Untested.
2021-10-31 Add alternate capture type that just saves off data values.
2021-10-31 Quick fix to HCT145 interposer. Reverse direction was outputting to wrong pins.
2021-10-31 Remove isaout from logicanalyzer.
2021-10-31 Test passes at data buffer IO code for XTA firmware.
2021-11-01 Add untested experimentation of control registers state machine program.
2021-11-01 PIO doodling.
2021-11-01 control_registers programs now compiling and look to be what we need.
2021-11-02 More tweaking of read_register_1. Repurposes pin 24 to trigger restoration of pindirs and data_dir, however this is not helpful as the code ends up needing to put the side channel set on the nop inst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
2021-11-02 More PIO tweaking
2021-11-03 Add a couple of comments to PIO.
2021-11-03 Experiments with reading VSYS ADC values as a hardware random number generator. Seems to work.
2021-11-03 Clean up control_registers.pio.
2021-11-03 Add sha1 code from https://github.com/clibs/sha1 (Public Domain).
2021-11-03 WIP on DeviceId class. Incomplete, not yet tested to compile.
2021-11-03 Add extern "C" to sha1.h
2021-11-03 Move DeviceId.h to Common folder. Add Common library for shared source files. Compiled and run. Appears to generate valid, unique device IDs.
2021-11-03 Fix compiler warning.
2021-11-04 Shited pin positions so DRQ and IRQ immediately follow address lines.
2021-11-04 Update board and schematic pdf to match latest changes.
2021-11-04 Create a small interposer board to avoid having to remake entire 4 layer board just to try a different pin mapping.
2021-11-04 Update schematic so Pico pinout matches the latest interposer layout. Appears to be a good match for code also.
2021-11-04 Remove serial config jumpers/IC. Just connect the boot override button. We will instead use USB serial to access a configuration menu and save configured options to the flash memory.
2021-11-04 Reorder Pico pins and fix direction of 245's.
2021-11-04 More pin reassignments.
2021-11-04 Add fatfs 0.14b.
2021-11-04 Add Pico SD SPI implementation for FatFs from https://github.com/elehobica/pico_fatfs_test
2021-11-04 Add FatFs and tf_card sources to build.
2021-11-04 Temporarily add main.cpp from tf_card for testing.
2021-11-04 tf_main called and compiling.
2021-11-05 Rename LogicAnaluzer main.cpp to la_main.cpp
2021-11-05 control_reigisters.pio compiling again.
2021-11-05 Rename 8_bit_ide.cpp to xta_main.cpp.
2021-11-05 Rename 8bit_ide_drive.uf2 to xta_firmware.uf2.
2021-11-05 Rename name of common generated library to common_lib.
2021-11-05 Add common library to xta_firmware build.
2021-11-05 Rename logic_analyzer.uf2 to LogicAnalyzer.uf2.
2021-11-05 Rename xta_firmware.uf2 to XtaFirmware.uf2
2021-11-05 Rename common_lib to CommonLib.
2021-11-05 Rename files to use preferred case style.
2021-11-05 Remove isaout from XtaFirmware.
2021-11-05 All targets now part of one CMake project.
2021-11-05 Move library dependencies to Common lib.
2021-11-05 Rename folder PicoFirmware to Firmware.
2021-11-05 Swap A0/A1 pin assignments.
2021-11-05 Add pullup resistors to ~IRQ and ~DRQ.
2021-11-05 Add IoConfig class and code to to initial pin initialization.
2021-11-05 Changes to IO pre-initialize. Setting of GPIO function is in progress.
2021-11-05 In read_register_1, invert DRQ and IRQ flags since the way we are driving those signals requires us to use inverted values on the pins.
2021-11-05 Add Db8Firmware target. Doodling with Dba8 control register programs. Dba8 appears to involve less pressure on PIO than XTA.
2021-11-06 Complete PreInitialize() method.
2021-11-06 Further PIO optimizations after discovering only one PIO unit can be assigned to pin writes for a given pin. This means all read handing must be on the same PIO and fit into 32 instructions. Seem to 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
2021-11-06 Add some comments to PIO about instructions counts / how to allocate the programs. Save a cycle in data_write.
2021-11-06 Update notes about min read setup time after finding smaller number in WD MFM controller manual.
2021-11-06 Add notes about the XTA registers.
2021-11-06 Add shell for LedController class.
2021-11-06 Complete first pass on LedController except for updating the PeripheralController LED.
2021-11-06 Add PeripheralController class. LED fucntion implemented and tested.
2021-11-06 Complete button support and button demo in PeripheralController.
2021-11-06 Fix position of Pico in schematic.
2021-11-06 Change pinout again.
2021-11-07 Separate out module demo code. Set up for simple unit tests.
2021-11-07 Moved tests to separate library.
2021-11-07 Implement tests for DeviceId.
2021-11-07 Minor cleanup of TestDeviceId.
2021-11-07 Implement LbaTranslation class and start work on unit tests for it.
2021-11-07 Complete LbaTranslation tests.
2021-11-07 Minor comment fix.
2021-11-08 Udate HCT145 interposer. Much simplified (removes the HCT145) and laid out for planning breadboard construction.
2021-11-08 LogicAnalyzer WIP changes.
2021-11-09 Start of alternate layout which better locates the SD cards. Also adds cutouts for side-screw clearance.
2021-11-09 Placeholder a couple of headers.
2021-11-10 Updates to logic analyzer.
2021-11-10 LogicAnalyzer tweaks.
2021-11-11 Call InitPins which got Logic Analyzer triggering working correctly. Pullups are also working correctly now. Other minor tweaks.
2021-11-11 Data values capture working.
2021-11-11 Improved formatting of data values.
2021-11-14 Fix some backwards branch logic in write_control_regs.
2021-11-14 Rename Isa.pio to XtBus.pio.
2021-11-14 Fix some backwards branch logic in read_control_register.
2021-11-14 Remove separate programs for reading register 1 and 2.
2021-11-15 Fix error in write_control_register where it would decode when ~CS and/or AEN were high.
2021-11-16 Intial multi-core mockup for the second core tight polling loop.
2021-11-16 WIP on asm polling loop. Not quite working yet. Seems that the asm loop is not running / halted the processor?
2021-11-17 A bunch of second core polling loop experiments. Finally figured out how to include a function in scratch_x and call it from C++.
2021-11-17 Simplify SecondCorePollingLoopCRef() back to original. Change how timing works.
2021-11-17 Time assembly code. Works! Expected 16 cycles per loop + 1 cycle for timing code.
2021-11-18 Shell for XtBus class.
2021-11-19 Update pin ordering in IoConfig.
2021-11-19 Load the write_control_register pio program.
2021-11-19 Disable internal pullups on pins with external pullups.
2021-11-19 write_control_register written and tested. Seems to be working correctly.
2021-11-19 Minor tweaks to debug output.
2021-11-19 Work towards getting register read to work.
2021-11-19 WIP on getting register reads to work. Seems than DATA_DIR is not getting set.
2021-11-20 PIO latency experiments.
2021-11-20 Minor steps forward with handling IO reads.
2021-11-21 Add code for DRQ and IRQ inversion, few other minor tweaks.
2021-11-21 Fix out pin mapping for read PIO programs. Previously it was incorrectly stomping the DATA_DIR value and/or pindir when setting data values/pindirs.
2021-11-21 Additional test code.
2021-11-21 read_control_register now working. Has test code in place - will remove in next commit.
2021-11-21 Cleaned up, working read_control_register PIO program.
2022-06-04 Update licenses.
2022-06-04 Update source files.
2022-06-04 Update board.
